

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO uart_ex_top 
  PIN PCLK 
    ANTENNAPARTIALMETALAREA 7.9584 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.8992 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 126.237 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 581.637 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.53786 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.4792 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2428 LAYER Metal5 ;
    ANTENNAGATEAREA 0.2592 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 152.343 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 701.579 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.98148 LAYER Via5 ;
  END PCLK
  PIN PRESETn 
    ANTENNAPARTIALMETALAREA 2.4096 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8432 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 34.8809 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 159.535 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.623362 LAYER Via4 ;
  END PRESETn
  PIN PSEL 
    ANTENNAPARTIALMETALAREA 2.3944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7748 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 106.421 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 484.533 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.48718 LAYER Via4 ;
  END PSEL
  PIN PENABLE 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1236 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 90.5573 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 413.149 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.48718 LAYER Via4 ;
  END PENABLE
  PIN PWRITE 
    ANTENNAPARTIALMETALAREA 1.9184 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6616 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 85.7983 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 392.718 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.48718 LAYER Via4 ;
  END PWRITE
  PIN PADDR[11] 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1236 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 104.829 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 481.344 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.02906 LAYER Via4 ;
  END PADDR[11]
  PIN PADDR[10] 
    ANTENNAPARTIALMETALAREA 2.3336 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5012 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 97.9145 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 446.103 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.8547 LAYER Via4 ;
  END PADDR[10]
  PIN PADDR[9] 
    ANTENNAPARTIALMETALAREA 2.5252 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3634 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 159.704 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 727.963 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.26543 LAYER Via4 ;
  END PADDR[9]
  PIN PADDR[8] 
    ANTENNAPARTIALMETALAREA 2.364 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.638 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 102.409 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 467.61 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.39829 LAYER Via4 ;
  END PADDR[8]
  PIN PADDR[7] 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1236 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 195.503 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 894.333 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.02778 LAYER Via4 ;
  END PADDR[7]
  PIN PADDR[6] 
    ANTENNAPARTIALMETALAREA 2.6984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1428 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06165 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 79.4937 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 367.843 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.09183 LAYER Via4 ;
  END PADDR[6]
  PIN PADDR[5] 
    ANTENNAPARTIALMETALAREA 2.3944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7748 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 230.42 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1050.81 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.37654 LAYER Via4 ;
  END PADDR[5]
  PIN PADDR[4] 
    ANTENNAPARTIALMETALAREA 2.2728 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2276 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 211.753 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 966.815 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.37654 LAYER Via4 ;
  END PADDR[4]
  PIN PADDR[3] 
    ANTENNAPARTIALMETALAREA 2.0448 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2016 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 226.568 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1033.48 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.37654 LAYER Via4 ;
  END PADDR[3]
  PIN PADDR[2] 
    ANTENNAPARTIALMETALAREA 2.5624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5308 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 217.333 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 991.741 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.62346 LAYER Via4 ;
  END PADDR[2]
  PIN PWDATA[31] 
  END PWDATA[31]
  PIN PWDATA[30] 
  END PWDATA[30]
  PIN PWDATA[29] 
  END PWDATA[29]
  PIN PWDATA[28] 
  END PWDATA[28]
  PIN PWDATA[27] 
  END PWDATA[27]
  PIN PWDATA[26] 
  END PWDATA[26]
  PIN PWDATA[25] 
  END PWDATA[25]
  PIN PWDATA[24] 
  END PWDATA[24]
  PIN PWDATA[23] 
  END PWDATA[23]
  PIN PWDATA[22] 
  END PWDATA[22]
  PIN PWDATA[21] 
  END PWDATA[21]
  PIN PWDATA[20] 
  END PWDATA[20]
  PIN PWDATA[19] 
  END PWDATA[19]
  PIN PWDATA[18] 
  END PWDATA[18]
  PIN PWDATA[17] 
  END PWDATA[17]
  PIN PWDATA[16] 
  END PWDATA[16]
  PIN PWDATA[15] 
    ANTENNAPARTIALMETALAREA 3.0796 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8582 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 118.058 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 535.918 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.31966 LAYER Via3 ;
  END PWDATA[15]
  PIN PWDATA[14] 
    ANTENNAPARTIALMETALAREA 3.73 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.8138 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 135.097 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 613.579 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.31966 LAYER Via3 ;
  END PWDATA[14]
  PIN PWDATA[13] 
    ANTENNAPARTIALMETALAREA 2.9804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4118 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4512 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0592 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.7248 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 117.887 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.48718 LAYER Via4 ;
  END PWDATA[13]
  PIN PWDATA[12] 
    ANTENNAPARTIALMETALAREA 2.9196 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1382 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 112.123 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 509.21 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.31966 LAYER Via3 ;
  END PWDATA[12]
  PIN PWDATA[11] 
    ANTENNAPARTIALMETALAREA 2.946 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2858 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.8176 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.708 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 35.6376 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 166.995 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.48718 LAYER Via4 ;
  END PWDATA[11]
  PIN PWDATA[10] 
    ANTENNAPARTIALMETALAREA 2.594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7018 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 168.222 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 770.741 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 3.32099 LAYER Via3 ;
  END PWDATA[10]
  PIN PWDATA[9] 
    ANTENNAPARTIALMETALAREA 2.3452 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5534 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 328.321 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1489.59 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 3.07407 LAYER Via3 ;
  END PWDATA[9]
  PIN PWDATA[8] 
    ANTENNAPARTIALMETALAREA 3.0084 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5666 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 192.864 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 881.63 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 3.32099 LAYER Via3 ;
  END PWDATA[8]
  PIN PWDATA[7] 
    ANTENNAPARTIALMETALAREA 2.4732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1294 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 122.407 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 557.456 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[7]
  PIN PWDATA[6] 
    ANTENNAPARTIALMETALAREA 2.4572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0574 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 92.6222 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 423.426 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[6]
  PIN PWDATA[5] 
    ANTENNAPARTIALMETALAREA 2.3932 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7694 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 96.7795 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 442.133 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[5]
  PIN PWDATA[4] 
    ANTENNAPARTIALMETALAREA 2.9204 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1418 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 102.222 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 466.626 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[4]
  PIN PWDATA[3] 
    ANTENNAPARTIALMETALAREA 2.6748 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0654 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 93.8256 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 429.826 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[3]
  PIN PWDATA[2] 
    ANTENNAPARTIALMETALAREA 2.5988 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6946 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 96.4239 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 440.533 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[2]
  PIN PWDATA[1] 
    ANTENNAPARTIALMETALAREA 2.4876 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1942 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 88.465 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 404.718 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[1]
  PIN PWDATA[0] 
    ANTENNAPARTIALMETALAREA 2.4572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0574 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 86.906 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 397.703 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.83932 LAYER Via3 ;
  END PWDATA[0]
  PIN PRDATA[31] 
  END PRDATA[31]
  PIN PRDATA[30] 
  END PRDATA[30]
  PIN PRDATA[29] 
  END PRDATA[29]
  PIN PRDATA[28] 
  END PRDATA[28]
  PIN PRDATA[27] 
  END PRDATA[27]
  PIN PRDATA[26] 
  END PRDATA[26]
  PIN PRDATA[25] 
  END PRDATA[25]
  PIN PRDATA[24] 
  END PRDATA[24]
  PIN PRDATA[23] 
  END PRDATA[23]
  PIN PRDATA[22] 
  END PRDATA[22]
  PIN PRDATA[21] 
  END PRDATA[21]
  PIN PRDATA[20] 
  END PRDATA[20]
  PIN PRDATA[19] 
  END PRDATA[19]
  PIN PRDATA[18] 
  END PRDATA[18]
  PIN PRDATA[17] 
  END PRDATA[17]
  PIN PRDATA[16] 
  END PRDATA[16]
  PIN PRDATA[15] 
    ANTENNADIFFAREA 0.79045 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.5636 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5362 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 38.9972 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 200.68 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.71339 LAYER Via3 ;
  END PRDATA[15]
  PIN PRDATA[14] 
    ANTENNAPARTIALMETALAREA 2.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.056 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2808 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.11135 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.5352 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4372 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.4846 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 250.405 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.15983 LAYER Via5 ;
  END PRDATA[14]
  PIN PRDATA[13] 
    ANTENNAPARTIALMETALAREA 2.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1168 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5544 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.11135 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.5384 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4516 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.4641 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 250.313 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.15983 LAYER Via5 ;
  END PRDATA[13]
  PIN PRDATA[12] 
    ANTENNAPARTIALMETALAREA 1.9772 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.8974 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1776 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.828 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.11135 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.5064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.3076 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.6282 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 251.051 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.15983 LAYER Via5 ;
  END PRDATA[12]
  PIN PRDATA[11] 
    ANTENNAPARTIALMETALAREA 2.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2096 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.972 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.11135 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.5384 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4516 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.3 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 249.574 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.15983 LAYER Via5 ;
  END PRDATA[11]
  PIN PRDATA[10] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.4252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9134 LAYER Metal3 ;
  END PRDATA[10]
  PIN PRDATA[9] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.1996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8982 LAYER Metal3 ;
  END PRDATA[9]
  PIN PRDATA[8] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.5212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3454 LAYER Metal3 ;
  END PRDATA[8]
  PIN PRDATA[7] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.4092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8414 LAYER Metal3 ;
  END PRDATA[7]
  PIN PRDATA[6] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.2452 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1034 LAYER Metal3 ;
  END PRDATA[6]
  PIN PRDATA[5] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.5156 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.349 LAYER Metal3 ;
  END PRDATA[5]
  PIN PRDATA[4] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.1844 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8298 LAYER Metal3 ;
  END PRDATA[4]
  PIN PRDATA[3] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.4092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8414 LAYER Metal3 ;
  END PRDATA[3]
  PIN PRDATA[2] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.5524 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4858 LAYER Metal3 ;
  END PRDATA[2]
  PIN PRDATA[1] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.4092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8414 LAYER Metal3 ;
  END PRDATA[1]
  PIN PRDATA[0] 
    ANTENNADIFFAREA 0.78365 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.4732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1294 LAYER Metal3 ;
  END PRDATA[0]
  PIN PREADY 
  END PREADY
  PIN PSLVERR 
  END PSLVERR
  PIN UARTRXD 
    ANTENNAPARTIALMETALAREA 2.5672 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5524 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 97.3949 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 443.918 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.48718 LAYER Via4 ;
  END UARTRXD
  PIN UARTTXD 
    ANTENNAPARTIALMETALAREA 7.4896 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.7032 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.3524 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 0.9952 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.536 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1917 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 15.9909 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 94.2466 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.46553 LAYER Via5 ;
  END UARTTXD
  PIN UARTRXINTR 
    ANTENNADIFFAREA 1.11135 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.0712 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.3492 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1494 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 77.8255 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 363.931 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.10776 LAYER Via4 ;
  END UARTRXINTR
  PIN UARTTXINTR 
    ANTENNADIFFAREA 1.6285 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.3016 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3572 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22095 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 39.1439 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 195.288 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.42536 LAYER Via4 ;
  END UARTTXINTR
  PIN UARTRTINTR 
    ANTENNADIFFAREA 1.6285 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.6544 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.4736 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22095 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 50.0814 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 235.524 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.42536 LAYER Via4 ;
  END UARTRTINTR
  PIN UARTEINTR 
    ANTENNADIFFAREA 0.782 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.036 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 42.7806 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 222.089 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.60798 LAYER Via4 ;
  END UARTEINTR
  PIN UARTINTR 
    ANTENNADIFFAREA 0.782 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.036 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 39.4986 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 207.32 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.60798 LAYER Via4 ;
  END UARTINTR
END uart_ex_top

END LIBRARY
